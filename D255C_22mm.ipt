# Autodesk Inventor part: D255C_22mm
## iProperties
Created: 2011-03
Part Number: D255C_22mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
